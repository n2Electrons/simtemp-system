## simtemp/kernel/Kconfig
```kconfig
config _SIMTEMP
        tristate " Temperature Simulator"
        help
          Temperature simulator driver for testing.
```
